# Repository DanCrank/swamp-gas

File README.md:

# swamp-gas
Design for an illuminated saucer rocket

```
/3d-objects              STL files for 3D-printed parts
                         F3D and STEP files for complete rocket
/lighting-controller
  /arduino/swamp-gas     Arduino code for the lighting program
  /board                 design files for carrier PCB
    /images              images of the layout and manufactured board
```

Parts list:
- 29mm motor tube, 100mm long
- 2.6" body tube, 100mm long
- 29mm motor retainer
- 5 fins cut from 1/8" basswood, per template
- 2-meter Adafruit NeoPixel strand, 60 pixels/meter
- Adafruit Trinket M0
- Custom carrier PCB
- 4 green LEDs mounted in top of body tube to illuminate the dome
    (wired in parallel, with a current limiting resistor if needed)
- 400mAh LiPo battery (zip tied to one of the fins)
- 26 ga stranded wire
- 2-pin JST connectors for battery
- 3-pin Molex connectors for connection to NeoPixel strand
- 2-pin Molex connectors for connection to LEDs in dome
- Power switch (optional)

LED wiring is left as an exercise for the reader and will depend on
the specific LEDs and battery you use.

In the first flight, the saucer flipped nose-down at apogee and fell
in a stable nose-down orientation, so no parachute should be needed.
The nose cone can be permanently mounted in the motor tube with CA.
Make sure the ejection sharge is removed from the motor before flight.

First flight was at the St. Louis Rocketry Association Spooktacular
Night Launch on October 30, 2021.

https://youtu.be/KtkhaTuiWWw

Hardware and software designs in this repository are distributed under
GNU GPLv3. (See COPYING for full license.)

## KiCad design lighting-controller/board/swampgas.kicad_pcb

File lighting-controller/board/README:

Board designed with KiCad 5.1.6. https://www.kicad-pcb.org

Parts:
C1: OPT; CP_Radial_D10.0mm_P5.00mm
H1, H2, H3: MountingHole; MountingHole_2.7mm_M2.5
J1: LiPo 3.7V; JST_PH_S2B-PH-K_1x02_P2.00mm_Horizontal
J2: NeoPixel; Molex_SPOX_5268-03A_1x03_P2.50mm_Horizontal
J3: Dome; Molex_SPOX_5268-02A_1x02_P2.50mm_Horizontal
R1, R2, R3, R4, R5, R6, R7, R8: 10k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R9: 470; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
SW1: SW_DIP_x08; DIP-16_W7.62mm
U1: Adafruit Trinket M0; ADAFRUIT_TRINKET_M0; Manufacturer_Part_Number 3500
U2: CD4512BE; DIP-16_W7.62mm

Connections:
GND: C1.2, J1.2, J2.3, J3.2, SW1.1, SW1.2, SW1.3, SW1.4, SW1.5, SW1.6, SW1.7, SW1.8, U1.2 (GND), U2.8 (VSS), U2.10 (INHIBIT), U2.15 (3-STATE_DISABLE)
unnamed: J2.2, R9.1
unnamed: R1.2, SW1.16, U2.9 (D7)
unnamed: R2.2, SW1.15, U2.7 (D6)
unnamed: R3.2, SW1.14, U2.6 (D5)
unnamed: R4.2, SW1.13, U2.5 (D4)
unnamed: R5.2, SW1.12, U2.4 (D3)
unnamed: R6.2, SW1.11, U2.3 (D2)
unnamed: R7.2, SW1.10, U2.2 (D1)
unnamed: R8.2, SW1.9, U2.1 (D0)
unnamed: R9.2, U1.3 (#4)
unnamed: U1.4 (#3), U2.14 (SEL.OUTPUT)
unnamed: U1.7 (#2), U2.12 (B)
unnamed: U1.8 (#1), U2.11 (A)
unnamed: U1.9 ('0), U2.13 (C)
VCC: C1.1, J1.1, J2.1, J3.1, R1.1, R2.1, R3.1, R4.1, R5.1, R6.1, R7.1, R8.1, U1.1 (BAT+), U2.16 (VDD)

Notes on the sheet:
Optional filter capacitor to protect NeoPixels from power surges; see the NeoPixel UberGuide under "basic connections."

Board: 2 copper layers, 71.1 x 45.7 mm, 19 parts (0 on the bottom side), 16 nets.

## Commit log

2017-12-31 Initial OR design and rendering.
2020-01-02 Add .gitattributes for language
2020-08-29 Added lighting controller
2020-09-05 Lighting controller code update
    This version of the lighting controller has a very noticable delay in
    the animation cycle while it reads the dip switch (even without the
    settle delay in the dip switch function). CircuitPython does not
    natively support any kind of threading or async. Researching this
    but might convert to native Arduino if that can handle it better.
2020-09-06 Convert from CircuitPython to Arduino
    Due to problems interleaving the dip switch read function with
    the lighting animation in CircuitPython, I rewrote this using
    the Arduino libraries - much faster! :)
2020-09-07 Refactor dynamic color code
    Refactored to make it easier to add other dynamic colors besides
    rainbow; updated the rainbow code to use millis() to drive changes
    instead of a loop counter and allow variation of cycle speed.
2020-09-07 Added pulse pattern and GPL license
    Also bumped Arduino code down a level into an "arduino" directory
    and removed the old CircuitPython file.
2020-09-07 Added README for board.
2020-09-13 3D design for fin and fin guide
    Polished up the Fusion360 model and exported a fin template and a
    guide to hold the fins to the motor tube for assembly.
2021-10-30 Version 1.1 - flying Oct 30 2021!
2021-11-02 Full update after first flight
2021-11-02 Markdown reformatting
2022-10-26 Lighting update for Halloween 2022
